# Repository jazzkr/micro_drone

File README.md:

View this project on [CADLAB.io](https://cadlab.io/project/22757). 

# micro_drone
Micro drone project -- description TBD

## KiCad design hw/main_logic_board/main_logic_board.kicad_pcb

Board: 4 copper layers, 61.9 x 69.0 mm, 116 parts (57 on the bottom side), 75 nets.

Parts:
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E4000-R1
C1: 47uF; C_0805_2012Metric
C2, C3, C7, C8, C9, C10, C11, C12: 10u; C_0805_2012Metric
C4, C5, C13, C14, C20, C21, C22: 100n; C_0805_2012Metric
C6: 1n; C_0805_2012Metric
C15, C16, C17, C18, C19: 22u; C_0805_2012Metric
C23: 10uF; C_0805_2012Metric
D1, D2, D3, D4: WS2813; LED_WS2812_PLCC6_5.0x5.0mm_P1.6mm
D5: RED; D_0805_2012Metric
D6, D7, D8: LED; D_0805_2012Metric
D9: 5V_RED; D_0805_2012Metric
D10: 3V3_RED; D_0805_2012Metric
F1: Fuse; Fuse_1206_3216Metric
G1: LOGO; drone_icon
H1, H6, H7, H12: GND; MountingHole_2.2mm_M2_Pad_Via
H2, H5, H8, H11: SIG; MountingHole_2.2mm_M2_Pad_Via
H3, H4, H9, H10: PWR; MountingHole_2.2mm_M2_Pad_Via
J1: BATT_IN; SolderWirePad_1x02_P5.08mm_Drill1.5mm
J2: 5V_PWR_SEL; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
J3: 3V3_PWR_SEL; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
J4: USB_A; USB_A_Stewart_SS-52100-001_Horizontal
J5: RC_OUT_1; PinHeader_1x03_P2.54mm_Vertical
J6: RC_OUT_2; PinHeader_1x03_P2.54mm_Vertical
J7: RC_OUT_3; PinHeader_1x03_P2.54mm_Vertical
J8: RC_OUT_4; PinHeader_1x03_P2.54mm_Vertical
J11: SPI1; PinHeader_2x03_P1.27mm_Vertical_SMD
J12: UART0; PinHeader_1x03_P1.27mm_Vertical
J13: UART2; PinHeader_1x03_P1.27mm_Vertical
J14: UART4; PinHeader_1x03_P1.27mm_Vertical
J15: I2C1; PinHeader_1x03_P1.27mm_Vertical
J16: I2C2; PinHeader_1x03_P1.27mm_Vertical
J17: 5V; PinHeader_1x04_P1.27mm_Vertical
J18: 3V3; PinHeader_1x04_P1.27mm_Vertical
J19: BATT_V; PinHeader_1x04_P1.27mm_Vertical
L1: 3.3u 20mOhm; L_Abracon_ASPI-0630LR
L2: 2.2u 15mOhm; L_Vishay_IHLP-2020
R1: 56.2K 1%; R_0805_2012Metric
R2, R4: 10K 1%; R_0805_2012Metric
R3: 33.2K 1%; R_0805_2012Metric
R5, R11, R12, R13, R14: 0R; R_0805_2012Metric
R6, R8, R9, R10, R23, R24, R25, R26: 10K; R_0805_2012Metric
R7, R15, R16, R17, R18, R19: 1K; R_0805_2012Metric
R20: 5K1 0.1%; R_0805_2012Metric
R21: 820R 0.1%; R_0805_2012Metric
R22: 0R; R_2816_7142Metric_Pad3.20x4.45mm_HandSolder
SW1: ESP_RESET; SW_SPST_B3U-1000P
SW2: ESP_GPIO0; SW_SPST_B3U-1000P
TP1: TP_5V_VIN; TestPoint_Pad_D1.0mm
TP2: TP_3V3_PB; TestPoint_Pad_D1.0mm
TP3: TP_VOUT; TestPoint_Pad_D1.0mm
TP4: AIN_VREF+; TestPoint_Pad_D1.0mm
TP5: GPIO27; TestPoint_Pad_D1.0mm
TP6: AIN_1; TestPoint_Pad_D1.0mm
TP7: SPI1_CS1; TestPoint_Pad_D1.0mm
TP8: RC_IN; TestPoint_Pad_D1.0mm
TP10: USB_VIN; TestPoint_Pad_D1.0mm
U1: PocketBeagle; BeagleBoard_PocketBeagle_SMD
U2: 74LVC2T45DC; VSSOP-8_2.3x2mm_P0.5mm
U3: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering
U4: NCP1117-5.0_SOT223; SOT-223-3_TabPin2
U5: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U6, U7: TPS563200; SOT-23-6
U8: ESP-12F; ESP-12E
U9: USBLC6-2P6; SOT50P160X60-6N
U10: ICM-20948; InvenSense_QFN-24_3x3mm_P0.4mm
U11: VL53L1X; ST_VL53L1x
U12: ACS725xLCTR-40AB; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C4.1, C5.1, C8.1, C16.1, C18.1, C19.1, C20.1, C22.1, C23.1, D5.2, J11.1, J18.1, J18.2, L2.2, R3.1, R6.1, R8.1, R10.1, R19.1, R23.2, R24.2, R25.2, R26.1, U2.1, U2.5, U3.6, U3.8, U5.2, U8.8, U10.8, U10.13, U11.1, U11.11, U12.8
+5V: C1.1, C3.1, C15.1, C17.1, D1.2, D2.2, D3.2, D4.2, J17.1, J17.2, L1.2, R1.1, R5.1, R18.1, TP1.1, U1.1, U1.5, U2.8, U4.2
+BATT: H3.1, H4.1, H9.1, H10.1, J2.2, J3.2, J5.1, J6.1, J7.1, J8.1, J19.1, J19.2, R20.1, R22.2, U12.3, U12.4
/3V3_PB: TP2.1, U1.14
/AIN_1V8_0: R20.2, R21.1, U1.19
/AIN_1V8_1: TP6.1, U1.21
/AIN_3V3: U1.71, U12.7
/GPIO20: R15.1, U1.20
/GPIO23: R16.1, U1.39
/GPIO26: R17.1, U1.34
/GPIO27: TP5.1, U1.55
/I2C1_SCL: J15.1, R23.1, U1.45, U11.10
/I2C1_SDA: J15.2, R24.1, U1.47, U11.9
/I2C2_SCL: J16.1, R25.1, U1.28, U3.4, U10.23
/I2C2_SDA: J16.2, R26.2, U1.26, U3.3, U10.24
/LED_DATA: U1.35, U2.2
/PWM1: BZ1.1, U1.37
/RC_IN: TP8.1, U1.54
/RC_OUT_1: J5.2, R11.2, U1.29
/RC_OUT_2: J6.2, R12.2, U1.31
/RC_OUT_3: J7.2, R13.2, U1.33
/RC_OUT_4: J8.2, R14.2, U1.70
/SPI1_CLK: J11.3, U1.65
/SPI1_CS0: J11.4, U1.67
/SPI1_CS1: TP7.1, U1.66
/SPI1_MISO: J11.2, U1.63
/SPI1_MOSI: J11.5, U1.61
/UART0_RX: J12.2, U1.32
/UART0_TX: J12.1, U1.30
/UART2_RX: J13.2, U1.10
/UART2_TX: J13.1, U1.8
/UART4_RX: J14.2, U1.41, U8.22
/UART4_TX: J14.1, U1.43, U8.21
/power/BATT_FUSED: F1.1, R22.1, U12.1, U12.2
/power/BATT_VIN_3V3: C10.1, C12.1, J3.1, U7.3, U7.5
/power/BATT_VIN_5V: C9.1, C11.1, J2.1, U6.3, U6.5
/power/SW_NODE_3V3: C14.1, L2.1, U7.2
/power/SW_NODE_5V: C13.1, L1.1, U6.2
/telemetry/CH_PD: R10.2, U8.3
/telemetry/GPIO0: R7.2, SW2.2, U8.18
/telemetry/GPIO2: R8.2, U8.17
/telemetry/GPIO15: R9.1, U8.16
/telemetry/RST_N: R6.2, SW1.2, U8.1
GND: BZ1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, D1.5, D2.5, D3.5, D4.5, D6.1, D7.1, D8.1, D9.1, D10.1, H1.1, H6.1, H7.1, H12.1, J1.1, J4.4, J4.5, J5.3, J6.3, J7.3, J8.3, J11.6, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J17.4, J18.3, J18.4, J19.3, J19.4, R2.2, R4.2, R9.2, R21.2, SW1.1, SW2.1, U1.13, U1.15, U1.16, U1.17, U1.22, U1.51, U1.57, U2.4, U3.1, U3.7, U4.1, U5.1, U6.1, U7.1, U8.15, U9.2, U10.11, U10.18, U10.20, U11.2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
unnamed: C2.1, J2.3, U4.3
unnamed: C6.1, U12.6
unnamed: C7.1, J3.3, U5.3
unnamed: C13.2, U6.6
unnamed: C14.2, U7.6
unnamed: C21.1, U10.10
unnamed: D1.3, D2.4
unnamed: D1.4, U2.7
unnamed: D2.3, D3.4
unnamed: D3.3, D4.4
unnamed: D5.1, R7.1
unnamed: D6.2, R15.2
unnamed: D7.2, R16.2
unnamed: D8.2, R17.2
unnamed: D9.2, R18.2
unnamed: D10.2, R19.2
unnamed: F1.2, J1.2
unnamed: H2.1, R11.1
unnamed: H5.1, R12.1
unnamed: H8.1, R13.1
unnamed: H11.1, R14.1
unnamed: J4.1, R5.2, U9.5
unnamed: J4.2, U9.6
unnamed: J4.3, U9.4
unnamed: R1.2, R2.1, U6.4
unnamed: R3.2, R4.1, U7.4
unnamed: TP3.1, U1.49
unnamed: TP4.1, U1.18
unnamed: TP10.1, U1.7
unnamed: U1.9, U9.1
unnamed: U1.11, U9.3

## KiCad design hw/motor_arm/motor_arm.kicad_pcb

Parts:
C1, C2, C3, C5, C8: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4, C6, C9: 2.2uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D3: 1N4148; D_SOD-323_HandSoldering
H1, H7: PhaseA; MotorConnPads_3mmx4mm
H2, H8: PhaseB; MotorConnPads_3mmx4mm
H3, H9: PhaseC; MotorConnPads_3mmx4mm
H4: +12V; MountingHole_2.2mm_M2_Pad_Via
H5: RC_IN; MountingHole_2.2mm_M2_Pad_Via
H6: GND; MountingHole_2.2mm_M2_Pad_Via
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
R1, R5, R13, R14, R15, R16: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R3, R4, R6, R7, R8: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R9, R10, R11: 2.2k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R12, R17: 1k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: AP7370-33W5-7; AP7370_SOT25W5
U2, U5, U9: IR2101; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U3, U4, U6, U8, U10, U11: RF4E110GN; RF4E110GN_DFN2020-8S
U7: EFM8BB21F16I-C-QFN20; IC_EFM8BB21F16I-C-QFN20
U12, U13, U14: MIC4604YMT; MIC4604-TDFN2525-10

Connections:
+3V3: C2.1, C7.1, J1.3, R12.2, U1.5, U7.4 (VDD)
+12V: C1.1, C3.1, C5.1, C8.1, D1.2 (A), D2.2 (A), D3.2 (A), H4.1, U1.1, U2.1 (VCC), U3.1 (D), U3.2 (D), U3.5 (D), U3.6 (D), U3.7 (D), U5.1 (VCC), U6.1 (D), U6.2 (D), U6.5 (D), U6.6 (D), U6.7 (D), U9.1 (VCC), U10.1 (D), U10.2 (D), U10.5 (D), U10.6 (D), U10.7 (D), U12.1, U13.1, U14.1
AH: U2.2 (HIN), U7.13 (P1.1/P1MAT.1), U12.6
AL: U2.3 (LIN), U7.14 (P1.0/P1MAT.0), U12.7
BH: U5.2 (HIN), U7.10 (P1.3/P1MAT.3/I2C0_SCL), U13.6
BL: U5.3 (LIN), U7.11 (P1.2/P1MAT.2/I2C0_SDA), U13.7
C2CK: R12.1, TP1.1, U7.5 (~RSTB/!C2CK~)
C2D: TP2.1, U7.6 (P2.0/C2D)
CH: U7.8 (P1.5/P1MAT.5), U9.2 (HIN), U14.6
CL: U7.9 (P1.4/P1MAT.4), U9.3 (LIN), U14.7
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C8.2, H6.1, J1.5, R9.1, R10.1, R11.1, U1.2, U2.4 (COM), U4.4 (S), U4.8 (S), U5.4 (COM), U7.3 (GND), U7.12 (GND), U7.21 (GND), U8.4 (S), U8.8 (S), U9.4 (COM), U11.4 (S), U11.8 (S), U12.8, U12.11, U13.8, U13.11, U14.8, U14.11
unnamed: C4.1, D1.1 (K), U2.8 (VB), U12.3
unnamed: C6.1, D2.1 (K), U5.8 (VB), U13.3
unnamed: C9.1, D3.1 (K), U9.8 (VB), U14.3
unnamed: H5.1, R17.1
unnamed: R1.1, U3.3 (G)
unnamed: R1.2, U2.7 (HO), U12.4
unnamed: R5.1, U4.3 (G)
unnamed: R5.2, U2.5 (LO), U12.9
unnamed: R13.1, U6.3 (G)
unnamed: R13.2, U5.7 (HO), U13.4
unnamed: R14.1, U8.3 (G)
unnamed: R14.2, U5.5 (LO), U13.9
unnamed: R15.1, U10.3 (G)
unnamed: R15.2, U9.7 (HO), U14.4
unnamed: R16.1, U11.3 (G)
unnamed: R16.2, U9.5 (LO), U14.9
PhaseA: C4.2, H1.1, H7.1, R6.2, U2.6 (VS), U3.4 (S), U3.8 (S), U4.1 (D), U4.2 (D), U4.5 (D), U4.6 (D), U4.7 (D), U12.5
PhaseB: C6.2, H2.1, H8.1, R7.2, U5.6 (VS), U6.4 (S), U6.8 (S), U8.1 (D), U8.2 (D), U8.5 (D), U8.6 (D), U8.7 (D), U13.5
PhaseC: C9.2, H3.1, H9.1, R8.2, U9.6 (VS), U10.4 (S), U10.8 (S), U11.1 (D), U11.2 (D), U11.5 (D), U11.6 (D), U11.7 (D), U14.5
RX: J1.2, R17.2, U7.17 (P0.5/P0MAT.5/INT0.5/INT1.5/UART0_RX)
TX: J1.1, U7.18 (P0.4/P0MAT.4/INT0.4/INT1.4/UART0_TX)
vdA: R4.1, R6.1, R11.2, U7.20 (P0.2/P0MAT.2/INT0.2/INT1.2)
vdB: R3.1, R7.1, R10.2, U7.2 (P0.0/P0MAT.0/INT0.0/INT1.0)
vdC: R2.1, R8.1, R9.2, U7.1 (P0.1/P0MAT.1/INT0.1/INT1.1)

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
Board: 2 copper layers, 62.0 x 39.0 mm, 55 parts (0 on the bottom side), 36 nets.

## Commit log

2020-04-05 Backlink to CADLAB.io has been added.
2020-04-12 Initial commit of kicad projects
2020-04-16 Add datasheets and main devices in schematic
2020-04-19 adding initial drone mech layout
2020-04-24 Progress on MLB design
2020-04-24 Deleting redundant docs
2020-04-26 created first revision of mechanical assembly
2020-04-26 Added prop volumes and checked socket clearance
2020-04-26 added documentation for tinypepper esc and esc processor
2020-04-26 added nuts to the arm-body screws to check clearance
2020-04-27 Finish initial power schematics, swap some footprints for visualization in pcb view
2020-05-02 adding new variant of the drone parts in
2020-05-02 created dxf files for the arm and body
2020-05-04 Finish prelim schematic + PCB component placement
2020-05-04 Add datasheet + library files
2020-05-07 Add debug headers, LED wiring, remove MPU
2020-05-07 Add cache lib for cadlab
2020-05-07 Add 3D model files, lay out switching circuit, other tweaks
2020-05-07 Add freecad & step file of mlb
2020-05-07 Update mech CAD with kicad MLB output
2020-05-08 Finished motor arm schematic and started pcb layout
2020-05-08 Add power + GPIO LEDs
2020-05-09 created test pcb
2020-05-09 modified top layer to have routed 12 V rather than cu pour
2020-05-09 generated gerbers for esc v1
2020-05-10 adding battery holder
2020-05-10 adding battery
2020-05-12 Add current sensor, layout progress, and remove temp mech files
2020-05-13 Finish layout
2020-05-13 Layout tweaks to power plane
2020-05-13 Minor silk tweak
2020-05-13 Add more silk, + I2C pull ups
2020-05-13 Slight silk tweaks
2020-05-13 Some more slight silk adjustments + naming
2020-05-13 Add output + small tweaks to PCB
2020-05-13 Adding BOM information
2020-05-15 Add MLB BOM + fix mech assem + new 3D printable proto mech design
2022-01-25 Update repo with latest local
